Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[IFC4 Reference View]
Time: 2026-07-13T17:41:49
Written by: Processor version 6.0.0.0
Made in: Xbim.IO.MemoryModel

# IfcBuildingElementProxy (29)
In: Этаж
Системные параметры CADLib - Имя объекта: Соединение; Дата и время модификации: 23.06.2026 11:11:16; Категория: Деталь трубопровода; Статус: Открытый; Пользователь: MSK\MEVikulin; Индекс элемента: 1

# IfcFurnishingElement (58)
In: Этаж
Системные параметры CADLib - Дата и время модификации: 23.06.2026 11:11:16; Категория: Оборудование; Статус: Открытый; Пользователь: MSK\MEVikulin; Индекс элемента: 1
GSPI - Статус изделия: Проектируемое
Name | Имя объекта | Обозначение | Наименование
35 x Шкаф пожарный для размещения оборудования внутреннего пожарного крана и местом для двух огнетушителей, размером 540х230х1300(h), тип – навесной, исполнение – открытое, цвет – красный, дверь – правая. В комплекте с крепежом для крепления к стене. ШПК-320Н | Шкаф пожарный для размещения оборудования внутреннего пожарного крана и местом для двух огнетушителей, размером 540х230х1300(h), тип – навесной, исполнение – открытое, цвет – красный, дверь – правая. В комплекте с крепежом для крепления к стене. ШПК-320Н | ШПК-320НОК-п | Шкаф пожарный для размещения оборудования внутреннего пожарного крана и местом для двух огнетушителей, размером 540х230х1300(h), тип – навесной, исполнение – открытое, цвет – красный, дверь – правая. В комплекте с крепежом для крепления к стене.
23 x Шкаф пожарный для размещения оборудования внутреннего пожарного крана и местом для двух огнетушителей, размером 540х230х1300(h), тип – навесной, исполнение – открытое, цвет – красный, дверь – левая. В комплекте с крепежом для крепления к стене. ШПК-320НО | Шкаф пожарный для размещения оборудования внутреннего пожарного крана и местом для двух огнетушителей, размером 540х230х1300(h), тип – навесной, исполнение – открытое, цвет – красный, дверь – левая. В комплекте с крепежом для крепления к стене. ШПК-320НО | ШПК-320НОК-л | Шкаф пожарный для размещения оборудования внутреннего пожарного крана и местом для двух огнетушителей, размером 540х230х1300(h), тип – навесной, исполнение – открытое, цвет – красный, дверь – левая. В комплекте с крепежом для крепления к стене.

# IfcPipeFitting (166)
In: Этаж
Системные параметры CADLib - Дата и время модификации: 23.06.2026 11:11:16; Категория: Деталь трубопровода; Статус: Открытый; Пользователь: MSK\MEVikulin; Индекс элемента: 1
Name | Имя объекта | Обозначение | Наименование
4 x Отвод полипропиленовый 45° PP-H 110 (цвет коричневый) ТУ 4926-020-42943419-2009 (v.3) | Отвод полипропиленовый 45° PP-H 110 (цвет коричневый) ТУ 4926-020-42943419-2009 (v.3) | Отвод 45° PP-H 110 (цвет коричневый) | Отвод 45° из полипропилена для систем внутренней канализации
Тройник равнопроходный полипропиленовый 87.5° PP-H 110x110 ГОСТ 32414-2013 (v.2) | Тройник равнопроходный полипропиленовый 87.5° PP-H 110x110 ГОСТ 32414-2013 (v.2) | Тройник 87,5° PP-H 110х110 | Тройник равнопроходный 87.5° из полипропилена для систем внутренней канализации
2 x Переход 109х110 | Переход 109х110
8 x Отвод полипропиленовый 45° PP-H 50 ГОСТ 32414-2013 (v.3) | Отвод полипропиленовый 45° PP-H 50 ГОСТ 32414-2013 (v.3) | Отвод 45° PP-H 50 | Отвод 45° из полипропилена для систем внутренней канализации
10 x Отвод полипропиленовый 30° PP-H 50 ГОСТ 32414-2013 (v.3) | Отвод полипропиленовый 30° PP-H 50 ГОСТ 32414-2013 (v.3) | Отвод 30° PP-H 50 | Отвод 30° из полипропилена для систем внутренней канализации
17 x Отвод крутоизогнутый типа 3D стальной (исп.2) 90°, ст.20, 219x6 ГОСТ 17375-2001 (v.2) | Отвод крутоизогнутый типа 3D стальной (исп.2) 90°, ст.20, 219x6 ГОСТ 17375-2001 (v.2) | Отвод 90°-219х6 | Отвод крутоизогнутый типа 3D бесшовный приварной (исп.2) из углеродистой стали
3 x Тройник равнопроходный стальной (исп.2), ст.20, 219x6 ГОСТ 17376-2001 (v.2) | Тройник равнопроходный стальной (исп.2), ст.20, 219x6 ГОСТ 17376-2001 (v.2) | Тройник равнопроходный 219x6-20 | Тройник равнопроходный бесшовный приварной из углеродистой стали (исп.2)
70 x Отвод крутоизогнутый типа 3D стальной (исп.2) 90°, ст.20, 159x4.5 ГОСТ 17375-2001 (v.2) | Отвод крутоизогнутый типа 3D стальной (исп.2) 90°, ст.20, 159x4.5 ГОСТ 17375-2001 (v.2) | Отвод 90°-159х4.5 | Отвод крутоизогнутый типа 3D бесшовный приварной (исп.2) из углеродистой стали
4 x Отвод крутоизогнутый типа 3D стальной (исп.2) 90°, ст.20, 57x3 ГОСТ 17375-2001 (v.2) | Отвод крутоизогнутый типа 3D стальной (исп.2) 90°, ст.20, 57x3 ГОСТ 17375-2001 (v.2) | Отвод 90°-57х3 | Отвод крутоизогнутый типа 3D бесшовный приварной (исп.2) из углеродистой стали
Переход концентрический стальной (исп.2), ст.20, 219x6 - 159x4.5 ГОСТ 17378-2001 (v.2) | Переход концентрический стальной (исп.2), ст.20, 219x6 - 159x4.5 ГОСТ 17378-2001 (v.2) | Переход концентрический К - 219х6,0 - 159х4,5 | Переход концентрический бесшовный приварной (исп.2) из углеродистой стали
Переход концентрический стальной (исп.2), ст.20, 219x6 - 57x3 ГОСТ 17378-2001 (v.2) | Переход концентрический стальной (исп.2), ст.20, 219x6 - 57x3 ГОСТ 17378-2001 (v.2) | Переход концентрический К - 219х6,0 - 57х3,0 | Переход концентрический бесшовный приварной (исп.2) из углеродистой стали
30 x Отвод крутоизогнутый типа 3D стальной (исп.2) 45°, ст.20, 159x4.5 ГОСТ 17375-2001 (v.2) | Отвод крутоизогнутый типа 3D стальной (исп.2) 45°, ст.20, 159x4.5 ГОСТ 17375-2001 (v.2) | Отвод 45°-159х4.5 | Отвод крутоизогнутый типа 3D бесшовный приварной (исп.2) из углеродистой стали
5 x Отвод крутоизогнутый типа 3D стальной (исп.2) 90°, ст.20, 108x4 ГОСТ 17375-2001 (v.2) | Отвод крутоизогнутый типа 3D стальной (исп.2) 90°, ст.20, 108x4 ГОСТ 17375-2001 (v.2) | Отвод 90°-108х4 | Отвод крутоизогнутый типа 3D бесшовный приварной (исп.2) из углеродистой стали
Переход концентрический стальной (исп.2), ст.20, 159x4.5 - 108x4 ГОСТ 17378-2001 (v.2) | Переход концентрический стальной (исп.2), ст.20, 159x4.5 - 108x4 ГОСТ 17378-2001 (v.2) | Переход концентрический К - 159х4,5 - 108х4,0 | Переход концентрический бесшовный приварной (исп.2) из углеродистой стали
Переход концентрический стальной (исп.2), ст.20, 108x4 - 57x3 ГОСТ 17378-2001 (v.2) | Переход концентрический стальной (исп.2), ст.20, 108x4 - 57x3 ГОСТ 17378-2001 (v.2) | Переход концентрический К - 108х4,0 - 57х3,0 | Переход концентрический бесшовный приварной (исп.2) из углеродистой стали
6 x Тройник равнопроходный стальной (исп.2), ст.20, 159x4.5 ГОСТ 17376-2001 (v.2) | Тройник равнопроходный стальной (исп.2), ст.20, 159x4.5 ГОСТ 17376-2001 (v.2) | Тройник равнопроходный 159x4.5-20 | Тройник равнопроходный бесшовный приварной из углеродистой стали (исп.2)
2 x Отвод крутоизогнутый типа 3D стальной (исп.2) 45°, ст.20, 108x4 ГОСТ 17375-2001 (v.2) | Отвод крутоизогнутый типа 3D стальной (исп.2) 45°, ст.20, 108x4 ГОСТ 17375-2001 (v.2) | Отвод 45°-108х4 | Отвод крутоизогнутый типа 3D бесшовный приварной (исп.2) из углеродистой стали

# IfcPipeSegment (218)
In: Этаж
Системные параметры CADLib - Дата и время модификации: 23.06.2026 11:11:16; Категория: Деталь трубопровода; Статус: Открытый; Пользователь: MSK\MEVikulin; Индекс элемента: 1
Name | Имя объекта | Обозначение | Наименование
29 x Труба полипропиленовая PP-H 110х2.7 L=3000 ГОСТ 32414-2013 (v.3) | Труба полипропиленовая PP-H 110х2.7 L=3000 ГОСТ 32414-2013 (v.3) | Труба PP-H 110x2,7000000000 L=3000 мм | Труба из полипропилена для систем внутренней канализации
Труба полипропиленовая PP-H 110х2.7 L=2000 ГОСТ 32414-2013 (v.3) | Труба полипропиленовая PP-H 110х2.7 L=2000 ГОСТ 32414-2013 (v.3) | Труба PP-H 110x2,7000000000 L=2000 мм | Труба из полипропилена для систем внутренней канализации
2 x Труба полипропиленовая PP-H 110х3.4 SN4 L=2000 (цвет коричневый) ТУ 4926-020-42943419-2009 (v.3) | Труба полипропиленовая PP-H 110х3.4 SN4 L=2000 (цвет коричневый) ТУ 4926-020-42943419-2009 (v.3) | Труба PP-H 110x3,4000000000 SN4 L=2000 мм (цвет коричневый) | Труба из полипропилена для систем внутренней канализации
10 x Труба полипропиленовая PP-H 110х3.4 SN4 L=3000 (цвет коричневый) ТУ 4926-020-42943419-2009 (v.3) | Труба полипропиленовая PP-H 110х3.4 SN4 L=3000 (цвет коричневый) ТУ 4926-020-42943419-2009 (v.3) | Труба PP-H 110x3,4000000000 SN4 L=3000 мм (цвет коричневый) | Труба из полипропилена для систем внутренней канализации
4 x Труба полипропиленовая PP-H 110х3.4 SN4 L=500 (цвет коричневый) ТУ 4926-020-42943419-2009 (v.3) | Труба полипропиленовая PP-H 110х3.4 SN4 L=500 (цвет коричневый) ТУ 4926-020-42943419-2009 (v.3) | Труба PP-H 110x3,4000000000 SN4 L=500 мм (цвет коричневый) | Труба из полипропилена для систем внутренней канализации
9 x Труба полипропиленовая PP-H 50х1.8 L=500 ГОСТ 32414-2013 (v.3) | Труба полипропиленовая PP-H 50х1.8 L=500 ГОСТ 32414-2013 (v.3) | Труба PP-H 50x1,8000000000 L=500 мм | Труба из полипропилена для систем внутренней канализации
9 x Труба полипропиленовая PP-H 50х1.8 L=150 ГОСТ 32414-2013 (v.3) | Труба полипропиленовая PP-H 50х1.8 L=150 ГОСТ 32414-2013 (v.3) | Труба PP-H 50x1,8000000000 L=150 мм | Труба из полипропилена для систем внутренней канализации
9 x Труба полипропиленовая PP-H 50х1.8 L=3000 ГОСТ 32414-2013 (v.3) | Труба полипропиленовая PP-H 50х1.8 L=3000 ГОСТ 32414-2013 (v.3) | Труба PP-H 50x1,8000000000 L=3000 мм | Труба из полипропилена для систем внутренней канализации
21 x Труба 219х6, ст.20, ГОСТ 10704-91 (v.2) | Труба 219х6, ст.20, ГОСТ 10704-91 (v.2) | 219х6 | Трубы стальные электросварные прямошовные
110 x Труба 159х4.5, ст.20, ГОСТ 10704-91 (v.2) | Труба 159х4.5, ст.20, ГОСТ 10704-91 (v.2) | 159х4.5 | Трубы стальные электросварные прямошовные
6 x Труба 57х3, ст.20, ГОСТ 10704-91 (v.2) | Труба 57х3, ст.20, ГОСТ 10704-91 (v.2) | 57х3 | Трубы стальные электросварные прямошовные
8 x Труба 108х4, ст.20, ГОСТ 10704-91 (v.2) | Труба 108х4, ст.20, ГОСТ 10704-91 (v.2) | 108х4 | Трубы стальные электросварные прямошовные

# IfcSanitaryTerminal (167)
In: Этаж
Системные параметры CADLib - Дата и время модификации: 23.06.2026 11:11:16; Категория: Оборудование; Статус: Открытый; Пользователь: MSK\MEVikulin; Индекс элемента: 1
Name | Имя объекта | Наименование
68 x Унитаз тарельчатый с косым выпуском и смывным бачком в комплекте с сиденьем | Унитаз тарельчатый с косым выпуском и смывным бачком в комплекте с сиденьем | Унитаз тарельчатый с косым выпуском и смывным бачком в комплекте с сиденьем
77 x Умывальник полукруглый 550х420 | Умывальник полукруглый 550х420 | Умывальник полукруглый 550х420
22 x Поддон мелкий стальной эмалированный душевой ПДСм 800 | Поддон мелкий стальной эмалированный душевой ПДСм 800 | Поддон мелкий стальной эмалированный душевой | GSPI - Обозначение: ПДСм 800; Статус изделия: Проектируемое
